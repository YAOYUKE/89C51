# Keil uVision project LCD12864.uvproj, settings and files
target LCD12864 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\LCD12864
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LCD12864/: lcd12864.c
  group README
    ../README/: README.txt
